options:
  parameters:
    author: John Swoboda
    description: 'Creates a pfb sythesis of images and outputs them to an SDR. '
    generate_options: qt_gui
    id: welcome_sign
    output_language: python
    title: GR-Paint Welcom Sign
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '3'
  states: {}
- name: fc
  id: variable
  parameters:
    value: int(915e6)
  states: {}
- name: gain
  id: variable
  parameters:
    value: '100'
  states: {}
- name: pfb_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, M*samp_rate, samp_rate*.5, samp_rate/M, 80)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.4e6)
  states: {}
- name: blocks_file_source_0_1_0
  id: blocks_file_source
  parameters:
    file: images/0_open_radar_draft_02_flip.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: fc
    samplerate: samp_rate*M
    type: fc32
  states: {state: disabled}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '1'
    image_file: images/MIT_HO_logo_square.png
    image_flip: '0'
    image_invert: '0'
    repeatmode: '1'
  states: {}
- name: paint_image_source_0_0
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '1'
    image_file: images/MIT_HO_logo_square.png
    image_flip: '0'
    image_invert: '0'
    repeatmode: '1'
  states: {}
- name: paint_image_source_0_1
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '1'
    image_file: images/welcome-ni.png
    image_flip: '0'
    image_invert: '0'
    repeatmode: '1'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_ON
    randomsrc: INTERNAL
    repeats: '3'
    width: '2200'
  states: {}
- name: paint_paint_bc_0_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_ON
    randomsrc: INTERNAL
    repeats: '3'
    width: '2200'
  states: {}
- name: paint_paint_bc_0_1
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_ON
    randomsrc: INTERNAL
    repeats: '3'
    width: '2200'
  states: {}
- name: paint_paint_bc_0_1_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '8'
    width: '1067'
  states: {state: disabled}
- name: pfb_synthesizer_ccf_0
  id: pfb_synthesizer_ccf
  parameters:
    ch_map: '[]'
    connections: M
    numchans: M
    taps: pfb_taps
    twox: 'False'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*M
    fc: fc
    fftsize: '8192'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '10'
    freq0: fc
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0_1_0, '0', paint_paint_bc_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', pfb_synthesizer_ccf_0, '1']
- [blocks_throttle_0_0, '0', pfb_synthesizer_ccf_0, '2']
- [blocks_throttle_0_0_0, '0', pfb_synthesizer_ccf_0, '0']
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_image_source_0_0, '0', paint_paint_bc_0_0, '0']
- [paint_image_source_0_1, '0', paint_paint_bc_0_1, '0']
- [paint_paint_bc_0, '0', blocks_throttle_0, '0']
- [paint_paint_bc_0_0, '0', blocks_throttle_0_0, '0']
- [paint_paint_bc_0_1, '0', blocks_throttle_0_0_0, '0']
- [paint_paint_bc_0_1_0, '0', blocks_throttle_0_1_0, '0']
- [pfb_synthesizer_ccf_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
