options:
  parameters:
    author: John Swoboda
    description: Creates a pfb sythesis of images and outputs them to a pluto
    generate_options: qt_gui
    id: iapgrpaintdemo
    output_language: python
    title: IAP GR-Paint Demo
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '5'
  states: {}
- name: fc
  id: variable
  parameters:
    value: int(915e6)
  states: {}
- name: gain
  id: variable
  parameters:
    value: '100'
  states: {}
- name: pfb_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, M*samp_rate, samp_rate/2, samp_rate/5, 80)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.4e6)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: images/MIT_HO_logo_square_flip.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: images/mitadaptive_logo_flip.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: images/MIT_logo_flip.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_1_0
  id: blocks_file_source
  parameters:
    file: images/0_open_radar_draft_02_flip.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_1_0_0
  id: blocks_file_source
  parameters:
    file: images/hops_logo_d_icon_flip.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_1_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: fc
    samplerate: samp_rate*M
    type: fc32
  states: {state: disabled}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: fc
    samplerate: samp_rate*M
    type: fc32
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '4'
    width: '2200'
  states: {}
- name: paint_paint_bc_0_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_ON
    randomsrc: INTERNAL
    repeats: '4'
    width: '2467'
  states: {}
- name: paint_paint_bc_0_1
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '40'
    width: '320'
  states: {}
- name: paint_paint_bc_0_1_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '8'
    width: '1067'
  states: {state: disabled}
- name: paint_paint_bc_0_1_0_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '6'
    width: '756'
  states: {}
- name: pfb_synthesizer_ccf_0
  id: pfb_synthesizer_ccf
  parameters:
    ch_map: '[]'
    connections: M
    numchans: M
    taps: pfb_taps
    twox: 'False'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*M
    fc: '0'
    fftsize: '8192'
    plotconst: 'False'
    plottime: 'False'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '10'
    freq0: fc
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', paint_paint_bc_0, '0']
- [blocks_file_source_0_0, '0', paint_paint_bc_0_0, '0']
- [blocks_file_source_0_1, '0', paint_paint_bc_0_1, '0']
- [blocks_file_source_0_1_0, '0', paint_paint_bc_0_1_0, '0']
- [blocks_file_source_0_1_0_0, '0', paint_paint_bc_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_throttle_0, '0', pfb_synthesizer_ccf_0, '1']
- [blocks_throttle_0_0, '0', pfb_synthesizer_ccf_0, '2']
- [blocks_throttle_0_0_0, '0', pfb_synthesizer_ccf_0, '0']
- [blocks_throttle_0_1, '0', pfb_synthesizer_ccf_0, '4']
- [blocks_throttle_0_1_0_0, '0', pfb_synthesizer_ccf_0, '3']
- [paint_paint_bc_0, '0', blocks_throttle_0, '0']
- [paint_paint_bc_0_0, '0', blocks_throttle_0_0, '0']
- [paint_paint_bc_0_1, '0', blocks_throttle_0_1, '0']
- [paint_paint_bc_0_1_0, '0', blocks_throttle_0_1_0, '0']
- [paint_paint_bc_0_1_0_0, '0', blocks_throttle_0_1_0_0, '0']
- [pfb_synthesizer_ccf_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
